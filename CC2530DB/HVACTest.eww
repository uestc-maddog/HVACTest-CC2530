<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HVACTest.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>HVACTest</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>HVACTest</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>HVACTest</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>HVACTest</project>
        <configuration>CoordinatorEB-SBL</configuration>
      </member>
      <member>
        <project>HVACTest</project>
        <configuration>EndDeviceEB-SBL</configuration>
      </member>
      <member>
        <project>HVACTest</project>
        <configuration>RouterEB-SBL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


